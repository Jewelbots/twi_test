# Keil uVision project twi_sensor_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BSP_DEFINES_ONLY BOARD_JEWELBOT NRF51 DEBUG
  c misc: --c99
  c include: .\config\twi_sensor_pca10028;..\..\config;..\..\nrf51_sdk\components\toolchain;..\..\nrf51_sdk\components\drivers_nrf\common;..\..\nrf51_sdk\components\drivers_nrf\delay;..\..\nrf51_sdk\components\drivers_nrf\hal;..\..\nrf51_sdk\components\drivers_nrf\nrf_soc_nosd;..\..\nrf51_sdk\components\drivers_nrf\twi_master;..\..\nrf51_sdk\components\drivers_nrf\config;..\..\nrf51_sdk\components\drivers_nrf\uart;..\..\nrf51_sdk\components\libraries\fifo;..\..\nrf51_sdk\components\libraries\uart;..\..\nrf51_sdk\components\libraries\util;..\..\bsp;..\..\..\twi_test;..\..\..\twi_test;..\..\nrf51_sdk\components\drivers_ext\segger_rtt
  asm define: BSP_DEFINES_ONLY BOARD_JEWELBOT NRF51 DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c Actuator_Waveforms.c haptics_driver.c pmic_driver.c WaveformData.c Haptics.c
    ../../nrf51_sdk/components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_Drivers
    ../../nrf51_sdk/components/libraries/uart/: app_uart_fifo.c
    ../../nrf51_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nrf51_sdk/components/drivers_nrf/delay/: nrf_delay.c
    ../../nrf51_sdk/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../nrf51_sdk/components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../nrf51_sdk/components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../nrf51_sdk/components/libraries/uart/: retarget.c
    ../../nrf51_sdk/components/libraries/fifo/: app_fifo.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
